# Keil uVision project Contol FOC.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407IGTx STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Contol FOC +hex
  c flags: Optim=1
  c define: STM32F40XX, USE_STM324xG_EVAL, ARM_MATH_CM4, HSE_STARTUP_TIMEOUT = 0x5000, HSI_VALUE = 16000000,  HSE_VALUE = 26000000
  c include: .\RTE\Device\STM32F407IG;.\SystemDriveParams;.\SystemDriveParams\MCLibrary;.\SystemDriveParams\UILibrary;.\SystemDriveParams\MCApplication;.\src;.\STM32F4xx_StdPeriph_Driver\inc;.\STM32F4xx\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c stm32f4xx_Init_IRQ.c SystemInit.c
  group Startup
    ./: stm32f4xx_init.c
    ./STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group PeripheryLib
    ./src/: InitPin.c Keys.c spi.c UART.c Zettlex.c
  group StdPeriph_Driver_F4XX
    ./STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_spi.c misc.c
software components: CMSIS:CORE 3.20.0
